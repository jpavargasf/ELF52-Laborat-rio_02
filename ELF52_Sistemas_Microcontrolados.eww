<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Projects\Exerc_10\Exerc_10.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Exerc_11\Exerc_11.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Exerc_16\Exerc_16.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Exerc_17\Exerc_17.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Exerc_18\Exerc_18.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Exerc_20_5\Exerc_20_5.ewp</path>
    </project>
    <batchBuild />
</workspace>
